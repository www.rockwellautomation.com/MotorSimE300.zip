(* Logix 5000 Module export Motor_0; software revision 35.00 *)

MODULES
   Motor_0 : 193-ECM-ETR/A (Ethernet 192.168.1.10, rev 6.1, inhibited, StandardDataDriven RPI 100 ms)
END_MODULES
